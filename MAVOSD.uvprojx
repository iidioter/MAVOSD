# Keil uVision project MAVOSD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103OSD
  c flags: Optim=1 uC99=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\MAVLINK;.\MAVLINK\include\mavlink\v1.0;.\MAVLINK\include\mavlink\v1.0\ardupilotmega;.\MAVLINK\include\mavlink\v1.0\common;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10XLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c pins.c systick.c utils.c spi.c max7456.c usart.c OSDMavlink.c osdvar.c
